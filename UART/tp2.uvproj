# Keil uVision project tp2.uvproj, settings and files
target TP2 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(24000000) ELITTLE
  output: gpio
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ./init/: STM32F10x.s
  group Source
    ./: main.c
  group drv
    ./drv/: uart.c uart.h uart-priv.h rcc-priv.h afio-priv.h
    ../TP1/drv/: gpio.c gpio.h gpio-priv.h
